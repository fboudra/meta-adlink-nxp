FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI:append = " file://op_schema-range-loop-construct.patch"
